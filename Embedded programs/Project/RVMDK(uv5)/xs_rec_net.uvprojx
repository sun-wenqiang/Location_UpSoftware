# Keil uVision project xs_rec_net.uvprojx, settings and files
target STM32F407VGT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xs_rec_app_net +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\BoardDrivers\inc;..\..\Utilities;..\..\NetWork\w5500;..\..\NetWork\httpServer;..\..\NetWork;..\..\User;..\..\DSP_Lib\Include\dsp;..\..\DSP_Lib\Include;..\..\DSP_Lib\PrivateInclude;..\..\DSP_Lib\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group /MDK-ARM
    ../../Libraries/CMSIS/: startup_stm32f40xx.s startup_stm32f429_439xx.s
  group CMSIS
    ../../User/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_dac.c
  group BoardDrivers
    ../../Utilities/: stm324x7i_eval.c stm324x9i_eval.c
    ../../BoardDrivers/src/: delay.c at24c02.c spi.c iis.c cs5340.c cmd.c tim.c iwdg.c exti.c uart.c dma.c adc.c dac.c gain.c signal_process.c
  group NetWork
    ../../NetWork/w5500/: socket.c w5500.c wizchip_conf.c
    ../../NetWork/: net_conf.c
  group HttpServer
    ../../NetWork/httpServer/: httpParser.c httpServer.c
  group User
    ../../User/: main.c stm32f4xx_it.c
  group Doc
    ../../User/: readme.txt
  group DSP_Lib
    ../../DSP_Lib/: arm_cortexM4lf_math.lib
